# Autodesk Inventor part: 1_본체
## iProperties
Created: 2015-03
Part Number: 1_본체
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Author: Administrator
